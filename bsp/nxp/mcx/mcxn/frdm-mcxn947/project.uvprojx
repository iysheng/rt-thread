# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6210000::V6.21::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.19.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC, CPU_MCXN947VDF_cm33_core0, DEBUG, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, SERIAL_PORT_TYPE_UART=1
  c misc: --target=arm-arm-none-eabi
  c include: ../../../../../components/drivers/usb/cherryusb/class/dfu;../../../../../components/drivers/usb/cherryusb/class/hid;../Libraries/drivers/config;../../../../../components/libc/posix/io/poll;../../../../../components/drivers/usb/cherryusb/class/cdc;../../../../../components/drivers/include;../../../../../components/libc/posix/io/eventfd;../../../../../components/libc/compilers/common/extension/fcntl/octal;../../../../../libcpu/arm/cortex-m33;../../../../../components/utilities/ulog;../Libraries/CMSIS/Core/Include;../../../../../components/drivers/usb/cherryusb/class/video;../Libraries/MCXN947/MCXN947/drivers/romapi/mem_interface;../../../../../components/drivers/usb/cherryusb/class/vendor/net;../../../../../components/drivers/include;../../../../../components/drivers/usb/cherryusb/osal;applications;../../../../../components/drivers/usb/cherryusb/core;../Libraries/MCXN947/MCXN947/drivers/romapi/flash;../Libraries/drivers;../Libraries/MCXN947/MCXN947/drivers;../../../../../components/drivers/usb/cherryusb/class/wireless;../../../../../components/drivers/usb/cherryusb/common;../../../../../components/libc/posix/ipc;../../../../../components/drivers/usb/cherryusb/class/vendor/serial;../../../../../components/libc/compilers/common/extension;../Libraries/MCXN947/MCXN947;../Libraries/MCXN947/MCXN947/drivers/romapi/nboot;../../../../../components/drivers/include;../../../../../components/drivers/usb/cherryusb/class/midi;../../../../../components/drivers/usb/cherryusb/class/msc;../../../../../components/drivers/include;../../../../../include;../../../../../components/libc/posix/io/epoll;../Libraries/MCXN947/MCXN947/drivers/romapi/runbootloader;../../../../../components/drivers/usb/cherryusb/class/audio;../../../../../components/finsh;.;../../../../../libcpu/arm/common;../../../../../components/drivers/include;board;board/MCUX_Config/board;../../../../../components/libc/compilers/common/include;.\applications\middleware\usb\device;.\applications\middleware\usb\include;.\applications\debug_console;.\applications\osa;.\applications\serial_manager;.\applications\uart;.\applications\lists;.\applications\middleware\usb\phy;.\applications\str;.\applications\usb_device_cdc_vcom\bm\cm33_core0
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  link misc: --undefined=__scatterload_copy
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c cherryusb_port.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c cmd.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_lpcmp.c fsl_flexspi_edma.c fsl_lpuart_edma.c fsl_common.c fsl_itrc.c fsl_smartcard_phy_emvsim.c fsl_vref.c fsl_puf_v3.c fsl_irtc.c fsl_ostimer.c fsl_flexio_spi.c fsl_lptmr.c fsl_powerquad_matrix.c fsl_smartcard_emvsim.c fsl_syspm.c fsl_gdet.c fsl_flexio_mculcd_smartdma.c fsl_flexcan_edma.c fsl_mrt.c fsl_sema42.c fsl_sai.c fsl_cmc.c fsl_powerquad_data.c fsl_lpuart.c fsl_ewm.c fsl_evtg.c fsl_intm.c fsl_flexio_uart.c fsl_flexio_mculcd.c fsl_power.c fsl_smartdma.c fsl_dac14.c fsl_pint.c fsl_powerquad_transform.c fsl_wwdt.c fsl_clock.c fsl_smartdma_rt500.c fsl_trdc.c fsl_lpspi.c fsl_gpio.c fsl_edma.c fsl_flexio_mculcd_edma.c fsl_wuu.c fsl_spc.c fsl_lpspi_edma.c fsl_tdet.c fsl_flexio_i2c_master.c fsl_enet.c fsl_sinc.c fsl_usdhc.c fsl_powerquad_filter.c fsl_i3c.c fsl_flexio_spi_edma.c fsl_cdog.c fsl_flexspi.c fsl_ctimer.c fsl_eim.c fsl_sai_edma.c fsl_pdm_edma.c fsl_flexcan.c fsl_pdm.c fsl_lpi2c.c fsl_smartdma_mcxn.c fsl_dac.c fsl_freqme.c fsl_common_arm.c fsl_i3c_edma.c fsl_tsi_v6.c fsl_erm.c fsl_cache_lpcac.c fsl_flexio.c fsl_cache.c fsl_flexio_uart_edma.c fsl_sctimer.c fsl_opamp.c fsl_edma_soc.c fsl_lpi2c_edma.c fsl_powerquad_math.c fsl_plu.c fsl_utick.c fsl_vbat.c fsl_pwm.c fsl_powerquad_basic.c fsl_reset.c fsl_inputmux.c fsl_crc.c fsl_qdc.c fsl_lpadc.c fsl_lpflexcomm.c
    ../Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    ../Libraries/MCXN947/MCXN947/arm/: startup_MCXN947_cm33_core0.s
    ../Libraries/MCXN947/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
  group USB_VCOM
    ./applications/usb_device_cdc_vcom/bm/cm33_core0/: board.c clock_config.c pin_mux.c usb_device_cdc_acm.c usb_device_ch9.c usb_device_class.c usb_device_descriptor.c virtual_com.c
    ./applications/debug_console/: fsl_debug_console.c
    ./applications/str/: fsl_str.c
    ./applications/middleware/usb/device/: usb_device_ehci.c usb_device_dci.c
    ./applications/osa/: fsl_os_abstraction_bm.c
    ./applications/middleware/usb/phy/: usb_phy.c
    ./applications/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_port_uart.c
    ./applications/uart/: fsl_adapter_lpuart.c
